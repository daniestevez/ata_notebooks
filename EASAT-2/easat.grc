options:
  parameters:
    author: daniel
    generate_options: no_gui
    id: easat
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 3.84e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: easat.c64
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /mnt/buf0/EASAT-2_2022-01-15T18:07:37.955482_0x
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 180e3
    decim: '64'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 1, 0.45/64, 0.1/64)
    type: ccc
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
