options:
  parameters:
    author: daniel
    generate_options: no_gui
    id: polarimetry_4x
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: Record 4 channels
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: int(0.1 * samp_rate / (nfft * keep))
  states: {}
- name: fc
  id: variable
  parameters:
    value: 512e6
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: f'{directory}/{src_name}_{timestamp}_0xx'
    type: float
    vlen: nfft
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: f'{directory}/{src_name}_{timestamp}_0yy'
    type: float
    vlen: nfft
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: f'{directory}/{src_name}_{timestamp}_1xx'
    type: float
    vlen: nfft
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: f'{directory}/{src_name}_{timestamp}_1yy'
    type: float
    vlen: nfft
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: f'{directory}/{src_name}_{timestamp}_0xy'
    type: complex
    vlen: nfft
  states: {}
- name: blocks_file_sink_0_0_1_0
  id: blocks_file_sink
  parameters:
    file: f'{directory}/{src_name}_{timestamp}_1xy'
    type: complex
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: decim
    type: complex
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: decim
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: decim
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: decim
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_0_1
  id: blocks_integrate_xx
  parameters:
    decim: decim
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_1
  id: blocks_integrate_xx
  parameters:
    decim: decim
    type: complex
    vlen: nfft
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: keep
    type: complex
    vlen: nfft
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: keep
    type: complex
    vlen: nfft
  states: {}
- name: blocks_keep_one_in_n_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: keep
    type: complex
    vlen: nfft
  states: {}
- name: blocks_keep_one_in_n_0_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: keep
    type: complex
    vlen: nfft
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: nfft
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: nfft
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: directory
  id: parameter
  parameters:
    type: str
    value: '"/home/destevez/polarimetry/observations"'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    nthreads: '8'
    shift: 'True'
    type: complex
    window: window.rectangular(nfft)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    nthreads: '8'
    shift: 'True'
    type: complex
    window: window.rectangular(nfft)
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    nthreads: '8'
    shift: 'True'
    type: complex
    window: window.rectangular(nfft)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    nthreads: '8'
    shift: 'True'
    type: complex
    window: window.rectangular(nfft)
  states: {}
- name: gaindB
  id: parameter
  parameters:
    label: rx gain in decibels
    short_id: g
    type: eng_float
    value: '50'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: keep
  id: parameter
  parameters:
    short_id: k
    type: intx
    value: '4'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sampling rate [Hz]
    short_id: b
    type: eng_float
    value: 24.576e6
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      print(datetime.utcnow())
      self.uhd_usrp_source_0.set_lo_export_enabled(True, "lo1", 0)
      self.uhd_usrp_source_0.set_rx_lo_dist(True, "LO_OUT_0")
      self.uhd_usrp_source_0.set_rx_lo_dist(True, "LO_OUT_1")
      self.uhd_usrp_source_0.set_lo_source("external", "lo1", 0)
      self.uhd_usrp_source_0.set_lo_source("external", "lo1", 1)
      self.uhd_usrp_source_0.set_lo_source("external", "lo1", 2)
      self.uhd_usrp_source_0.set_lo_source("external", "lo1", 3)
    priority: ''
    section: main_after_init
  states: {}
- name: src_name
  id: parameter
  parameters:
    type: str
    value: '''unknown_source'''
  states: {}
- name: timestamp
  id: parameter
  parameters:
    type: str
    value: datetime.utcnow().isoformat()
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    ant2: RX2
    ant3: RX2
    center_freq0: fc
    center_freq1: fc
    center_freq2: fc
    center_freq3: fc
    clock_rate: '0.0'
    clock_source0: external
    clock_source1: external
    dc_offs_enb0: 'False'
    dc_offs_enb1: 'False'
    dc_offs_enb2: '""'
    dc_offs_enb3: '""'
    dev_addr: '"addr0=10.11.2.61, addr1=10.11.2.71"'
    dev_args: '""'
    gain0: gaindB
    gain1: gaindB
    gain2: gaindB
    gain3: gaindB
    iq_imbal_enb0: 'False'
    iq_imbal_enb1: 'False'
    iq_imbal_enb2: '""'
    iq_imbal_enb3: '""'
    nchan: '4'
    norm_gain0: 'False'
    norm_gain1: 'False'
    norm_gain2: 'False'
    norm_gain3: 'False'
    num_mboards: '2'
    otw: sc16
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    time_source1: external
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_integrate_xx_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_integrate_xx_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_1, '0', blocks_integrate_xx_0_0_1, '0']
- [blocks_integrate_xx_0, '0', blocks_file_sink_0_0_1, '0']
- [blocks_integrate_xx_0_0, '0', blocks_file_sink_0, '0']
- [blocks_integrate_xx_0_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_integrate_xx_0_0_0_0, '0', blocks_file_sink_0_0_0_0, '0']
- [blocks_integrate_xx_0_0_1, '0', blocks_file_sink_0_0_0, '0']
- [blocks_integrate_xx_0_1, '0', blocks_file_sink_0_0_1_0, '0']
- [blocks_keep_one_in_n_0, '0', fft_vxx_0, '0']
- [blocks_keep_one_in_n_0_0, '0', fft_vxx_0_0, '0']
- [blocks_keep_one_in_n_0_0_0, '0', fft_vxx_0_1, '0']
- [blocks_keep_one_in_n_0_0_0_0, '0', fft_vxx_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_integrate_xx_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', blocks_integrate_xx_0_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', blocks_keep_one_in_n_0_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', blocks_keep_one_in_n_0_0_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_0_0, '0', blocks_complex_to_mag_squared_0_0_0, '0']
- [fft_vxx_0_0_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [fft_vxx_0_1, '0', blocks_complex_to_mag_squared_0_1, '0']
- [fft_vxx_0_1, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '1', blocks_stream_to_vector_0_0, '0']
- [uhd_usrp_source_0, '2', blocks_stream_to_vector_0_0_0, '0']
- [uhd_usrp_source_0, '3', blocks_stream_to_vector_0_0_0_0, '0']

metadata:
  file_format: 1
