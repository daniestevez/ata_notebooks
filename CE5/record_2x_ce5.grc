options:
  parameters:
    author: daniel
    generate_options: no_gui
    id: record_2x_ce5
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: Record 2 channels
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '8'
  states: {}
- name: decim2
  id: variable
  parameters:
    value: '16'
  states: {}
- name: fc
  id: variable
  parameters:
    value: uhd.tune_request(512e6, 30.72e6)
  states: {}
- name: fir_taps
  id: variable
  parameters:
    value: firdes.low_pass(1e-3, samp_rate, 110e3, 3.62e6)
  states: {}
- name: fir_taps2
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate/decim, 110e3, 20e3)
  states: {}
- name: metadata
  id: variable
  parameters:
    value: pmt.dict_add(pmt.dict_add(pmt.dict_add(pmt.make_dict(), pmt.intern('source'), pmt.intern(src_name)), pmt.intern('lo_freq'), pmt.from_double(lo_freq)), pmt.intern('antennas'), pmt.intern(antennas))
  states: {}
- name: antennas
  id: parameter
  parameters:
    type: str
    value: '''1h'''
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: metadata
    file: f'{directory}/{src_name}_{timestamp}_0x_1'
    max_seg_size: int(samp_rate/(16*8))
    rel_rate: 1/(16*8)
    samp_rate: samp_rate/(16*8)
    type: complex
  states: {}
- name: blocks_file_meta_sink_0_1
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: metadata
    file: f'{directory}/{src_name}_{timestamp}_0x_0'
    max_seg_size: int(samp_rate/(16*8))
    rel_rate: 1/(16*8)
    samp_rate: samp_rate/(16*8)
    type: complex
  states: {}
- name: blocks_file_meta_sink_0_1_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: metadata
    file: f'{directory}/{src_name}_{timestamp}_0x_2'
    max_seg_size: int(samp_rate/(16*8))
    rel_rate: 1/(16*8)
    samp_rate: samp_rate/(16*8)
    type: complex
  states: {}
- name: blocks_file_meta_sink_0_1_0_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: metadata
    file: f'{directory}/{src_name}_{timestamp}_0y_2'
    max_seg_size: int(samp_rate/(16*8))
    rel_rate: 1/(16*8)
    samp_rate: samp_rate/(16*8)
    type: complex
  states: {}
- name: blocks_file_meta_sink_0_1_1
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: metadata
    file: f'{directory}/{src_name}_{timestamp}_0y_0'
    max_seg_size: int(samp_rate/(16*8))
    rel_rate: 1/(16*8)
    samp_rate: samp_rate/(16*8)
    type: complex
  states: {}
- name: blocks_file_meta_sink_0_2
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: metadata
    file: f'{directory}/{src_name}_{timestamp}_0x_3'
    max_seg_size: int(samp_rate/(16*8))
    rel_rate: 1/(16*8)
    samp_rate: samp_rate/(16*8)
    type: complex
  states: {}
- name: blocks_file_meta_sink_0_2_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: metadata
    file: f'{directory}/{src_name}_{timestamp}_0y_3'
    max_seg_size: int(samp_rate/(16*8))
    rel_rate: 1/(16*8)
    samp_rate: samp_rate/(16*8)
    type: complex
  states: {}
- name: blocks_file_meta_sink_0_3
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: metadata
    file: f'{directory}/{src_name}_{timestamp}_0y_1'
    max_seg_size: int(samp_rate/(16*8))
    rel_rate: 1/(16*8)
    samp_rate: samp_rate/(16*8)
    type: complex
  states: {}
- name: directory
  id: parameter
  parameters:
    type: str
    value: '"/mnt/buf0"'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decim2
    taps: fir_taps2
    type: ccf
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: decim2
    taps: fir_taps2
    type: ccf
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: decim2
    taps: fir_taps2
    type: ccf
  states: {}
- name: fir_filter_xxx_0_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: decim2
    taps: fir_taps2
    type: ccf
  states: {}
- name: fir_filter_xxx_0_0_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: decim2
    taps: fir_taps2
    type: ccf
  states: {}
- name: fir_filter_xxx_0_0_0_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: decim2
    taps: fir_taps2
    type: ccf
  states: {}
- name: fir_filter_xxx_0_0_0_0_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: decim2
    taps: fir_taps2
    type: ccf
  states: {}
- name: fir_filter_xxx_0_0_0_0_0_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: decim2
    taps: fir_taps2
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-3.7475e6'
    decim: decim
    samp_rate: samp_rate
    taps: fir_taps
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-11225e3'
    decim: decim
    samp_rate: samp_rate
    taps: fir_taps
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 3787500-63350
    decim: decim
    samp_rate: samp_rate
    taps: fir_taps
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 3787500-63350
    decim: decim
    samp_rate: samp_rate
    taps: fir_taps
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-11225e3'
    decim: decim
    samp_rate: samp_rate
    taps: fir_taps
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '11285000'
    decim: decim
    samp_rate: samp_rate
    taps: fir_taps
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '11285000'
    decim: decim
    samp_rate: samp_rate
    taps: fir_taps
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-3.7475e6'
    decim: decim
    samp_rate: samp_rate
    taps: fir_taps
    type: ccf
  states: {}
- name: gaindB
  id: parameter
  parameters:
    label: rx gain in decibels
    short_id: g
    type: eng_float
    value: '35'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: lo_freq
  id: parameter
  parameters:
    type: eng_float
    value: '8475'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sampling rate [Hz]
    short_id: b
    type: eng_float
    value: 30.72e6
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      self.uhd_usrp_source_0.set_time_next_pps(uhd.time_spec(int(time.time())+1))
      self.uhd_usrp_source_0.set_lo_export_enabled(True, "lo1", 0)
      self.uhd_usrp_source_0.set_rx_lo_dist(True, "LO_OUT_0")
      self.uhd_usrp_source_0.set_rx_lo_dist(True, "LO_OUT_1")
      self.uhd_usrp_source_0.set_lo_source("external", "lo1", 0)
      self.uhd_usrp_source_0.set_lo_source("external", "lo1", 1)
      time.sleep(1)
    priority: ''
    section: main_after_init
  states: {}
- name: src_name
  id: parameter
  parameters:
    type: str
    value: '''CE5'''
  states: {}
- name: timestamp
  id: parameter
  parameters:
    type: str
    value: datetime.utcnow().isoformat()
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    center_freq0: fc
    center_freq1: fc
    clock_rate: '0.0'
    clock_source0: external
    dc_offs_enb0: 'False'
    dc_offs_enb1: 'False'
    dev_addr: '"addr0=10.11.1.50"'
    dev_args: '""'
    gain0: gaindB
    gain1: gaindB
    iq_imbal_enb0: 'False'
    iq_imbal_enb1: 'False'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}

connections:
- [fir_filter_xxx_0, '0', blocks_file_meta_sink_0_1, '0']
- [fir_filter_xxx_0_0, '0', blocks_file_meta_sink_0, '0']
- [fir_filter_xxx_0_0_0, '0', blocks_file_meta_sink_0_1_0, '0']
- [fir_filter_xxx_0_0_0_0, '0', blocks_file_meta_sink_0_2, '0']
- [fir_filter_xxx_0_0_0_0_0, '0', blocks_file_meta_sink_0_1_1, '0']
- [fir_filter_xxx_0_0_0_0_0_0, '0', blocks_file_meta_sink_0_3, '0']
- [fir_filter_xxx_0_0_0_0_0_0_0, '0', blocks_file_meta_sink_0_1_0_0, '0']
- [fir_filter_xxx_0_0_0_0_0_0_0_0, '0', blocks_file_meta_sink_0_2_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', fir_filter_xxx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0, '0', fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0_0, '0', fir_filter_xxx_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0_0_0, '0', fir_filter_xxx_0_0_0_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0_1, '0', fir_filter_xxx_0_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_1, '0', fir_filter_xxx_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_1_0, '0', fir_filter_xxx_0_0_0_0_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_2, '0', fir_filter_xxx_0_0_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_1, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_1_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_1_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_1_1, '0']
- [uhd_usrp_source_0, '1', freq_xlating_fir_filter_xxx_0_1_0_0_0, '0']
- [uhd_usrp_source_0, '1', freq_xlating_fir_filter_xxx_0_1_0_1, '0']
- [uhd_usrp_source_0, '1', freq_xlating_fir_filter_xxx_0_1_1_0, '0']
- [uhd_usrp_source_0, '1', freq_xlating_fir_filter_xxx_0_1_2, '0']

metadata:
  file_format: 1
