options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: ce5_480k_phase
    output_language: python
    run_options: run
    title: Chang'e 5 telemetry decoder
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: 2*math.pi
    min_freq: '-2*math.pi'
    w: 2*math.pi*pll_bw/samp_rate
  states: {}
- name: analog_pll_refout_cc_0_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: 2*math.pi
    min_freq: '-2*math.pi'
    w: 2*math.pi*pll_bw/samp_rate
  states: {}
- name: analog_pll_refout_cc_0_0_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: 2*math.pi
    min_freq: '-2*math.pi'
    w: 2*math.pi*pll_bw/samp_rate
  states: {}
- name: analog_pll_refout_cc_0_0_0_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: 2*math.pi
    min_freq: '-2*math.pi'
    w: 2*math.pi*pll_bw/samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_off
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: basename
  id: parameter
  parameters:
    type: str
    value: '0'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: f'{basename}_phase_0x_{chan}'
    type: float
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: f'{basename}_phase_0y_{chan}'
    type: float
  states: {}
- name: blocks_file_sink_1_0_0
  id: blocks_file_sink
  parameters:
    file: f'{basename}_phase_1x_{chan}'
    type: float
  states: {}
- name: blocks_file_sink_1_0_0_0
  id: blocks_file_sink
  parameters:
    file: f'{basename}_phase_1y_{chan}'
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_0x_{chan}'
    offset: skip*samp_rate
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_0y_{chan}'
    offset: skip*samp_rate
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_1x_{chan}'
    offset: skip*samp_rate
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_1y_{chan}'
    offset: skip*samp_rate
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate*0.1)
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate*0.1)
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate*0.1)
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate*0.1)
    type: float
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: chan
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: freq_off
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pll_bw
  id: parameter
  parameters:
    type: eng_float
    value: '100'
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}
- name: satellites_rms_agc_0_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}
- name: satellites_rms_agc_0_0_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}
- name: satellites_rms_agc_0_0_0_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}
- name: skip
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}

connections:
- [analog_pll_refout_cc_0, '0', blocks_complex_to_arg_0, '0']
- [analog_pll_refout_cc_0_0, '0', blocks_complex_to_arg_0_0, '0']
- [analog_pll_refout_cc_0_0_0, '0', blocks_complex_to_arg_0_0_0, '0']
- [analog_pll_refout_cc_0_0_0_0, '0', blocks_complex_to_arg_0_0_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0_0_0_0, '1']
- [blocks_complex_to_arg_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_complex_to_arg_0_0_0, '0', blocks_keep_one_in_n_0_0_0, '0']
- [blocks_complex_to_arg_0_0_0_0, '0', blocks_keep_one_in_n_0_0_0_0, '0']
- [blocks_file_source_0, '0', satellites_rms_agc_0, '0']
- [blocks_file_source_0_0, '0', satellites_rms_agc_0_0, '0']
- [blocks_file_source_0_0_0, '0', satellites_rms_agc_0_0_0, '0']
- [blocks_file_source_0_0_0_0, '0', satellites_rms_agc_0_0_0_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_file_sink_1, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_file_sink_1_0, '0']
- [blocks_keep_one_in_n_0_0_0, '0', blocks_file_sink_1_0_0, '0']
- [blocks_keep_one_in_n_0_0_0_0, '0', blocks_file_sink_1_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', analog_pll_refout_cc_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', analog_pll_refout_cc_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0_0, '0', analog_pll_refout_cc_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0_0_0, '0', analog_pll_refout_cc_0_0_0_0, '0']
- [satellites_rms_agc_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [satellites_rms_agc_0_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [satellites_rms_agc_0_0_0, '0', blocks_multiply_conjugate_cc_0_0_0, '0']
- [satellites_rms_agc_0_0_0_0, '0', blocks_multiply_conjugate_cc_0_0_0_0, '0']

metadata:
  file_format: 1
