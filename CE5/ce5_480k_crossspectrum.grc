options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: ce5_480k_crossspectrum
    output_language: python
    run_options: run
    title: Chang'e 5 cross-spectrum
  states: {}

blocks:
- name: integ
  id: variable
  parameters:
    value: '10'
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: f'{inputprefix}_0xx_{chan}.crossspec'
    type: float
    vlen: nfft
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: f'{inputprefix}_0yy_{chan}.crossspec'
    type: float
    vlen: nfft
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: f'{inputprefix}_0xy_{chan}.crossspec'
    type: complex
    vlen: nfft
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: f'{inputprefix}_0x_{chan}.sigmf-data'
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: f'{inputprefix}_0y_{chan}.sigmf-data'
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int(samp_rate/nfft*integ)
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(samp_rate/nfft*integ)
    type: complex
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_1
  id: blocks_integrate_xx
  parameters:
    decim: int(samp_rate/nfft*integ)
    type: float
    vlen: nfft
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: nfft
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: chan
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(nfft)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(nfft)
  states: {}
- name: inputprefix
  id: parameter
  parameters:
    type: str
    value: '0'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_0_1, '0', blocks_integrate_xx_0_1, '0']
- [blocks_file_source_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_file_source_0_0, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_integrate_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_file_sink_0_1, '0']
- [blocks_integrate_xx_0_1, '0', blocks_file_sink_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_1, '0', fft_vxx_0_1, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_1, '0', blocks_complex_to_mag_squared_0_1, '0']
- [fft_vxx_0_1, '0', blocks_multiply_conjugate_cc_0, '1']

metadata:
  file_format: 1
