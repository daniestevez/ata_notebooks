options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: orx_waterfall
    output_language: python
    run_options: run
    title: ORX waterfall
  states: {}

blocks:
- name: dec
  id: variable
  parameters:
    value: '4'
  states: {}
- name: n_int
  id: variable
  parameters:
    value: round(samp_rate/dec/nfft * t_int)
  states: {}
- name: nfft
  id: variable
  parameters:
    value: 2**14
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 61.44e6
  states: {}
- name: t_int
  id: variable
  parameters:
    value: '1'
  states: {}
- name: basename
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_squared_0_2
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: f'{output}_0x'
    type: float
    vlen: nfft
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: f'{output}_0y'
    type: float
    vlen: nfft
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: f'{output}_1x'
    type: float
    vlen: nfft
  states: {}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: f'{output}_1y'
    type: float
    vlen: nfft
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_0x'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_0y'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_1x'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_1y'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: n_int
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: n_int
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_1
  id: blocks_integrate_xx
  parameters:
    decim: n_int
    type: float
    vlen: nfft
  states: {}
- name: blocks_integrate_xx_0_2
  id: blocks_integrate_xx
  parameters:
    decim: n_int
    type: float
    vlen: nfft
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_1
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_2
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: fft_vxx_0_2
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: output
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0_1, '0', blocks_integrate_xx_0_1, '0']
- [blocks_complex_to_mag_squared_0_2, '0', blocks_integrate_xx_0_2, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_interleaved_short_to_complex_0_1, '0']
- [blocks_file_source_0_0_0_0, '0', blocks_interleaved_short_to_complex_0_2, '0']
- [blocks_integrate_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_integrate_xx_0_1, '0', blocks_file_sink_0_1, '0']
- [blocks_integrate_xx_0_2, '0', blocks_file_sink_0_2, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_interleaved_short_to_complex_0_1, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_interleaved_short_to_complex_0_2, '0', blocks_stream_to_vector_0_2, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', fft_vxx_0_1, '0']
- [blocks_stream_to_vector_0_2, '0', fft_vxx_0_2, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [fft_vxx_0_1, '0', blocks_complex_to_mag_squared_0_1, '0']
- [fft_vxx_0_2, '0', blocks_complex_to_mag_squared_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
