options:
  parameters:
    author: daniel
    generate_options: no_gui
    id: record_4x
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: Record 4 channels
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: fc
  id: variable
  parameters:
    value: uhd.tune_request(500e6, 10e6)
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.dict_add(pmt.make_dict(), pmt.intern('source'), pmt.intern(src_name))
    file: f'{directory}/{src_name}_{timestamp}_0x'
    max_seg_size: int(samp_rate)
    rel_rate: '1'
    samp_rate: samp_rate
    type: short
    vlen: '2'
  states: {}
- name: blocks_file_meta_sink_0_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.dict_add(pmt.make_dict(), pmt.intern('source'), pmt.intern(src_name))
    file: f'{directory}/{src_name}_{timestamp}_0y'
    max_seg_size: int(samp_rate)
    rel_rate: '1'
    samp_rate: samp_rate
    type: short
    vlen: '2'
  states: {}
- name: blocks_file_meta_sink_0_0_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.dict_add(pmt.make_dict(), pmt.intern('source'), pmt.intern(src_name))
    file: f'{directory}/{src_name}_{timestamp}_1x'
    max_seg_size: int(samp_rate)
    rel_rate: '1'
    samp_rate: samp_rate
    type: short
    vlen: '2'
  states: {}
- name: blocks_file_meta_sink_0_0_0_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.dict_add(pmt.make_dict(), pmt.intern('source'), pmt.intern(src_name))
    file: f'{directory}/{src_name}_{timestamp}_1y'
    max_seg_size: int(samp_rate)
    rel_rate: '1'
    samp_rate: samp_rate
    type: short
    vlen: '2'
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int(0.1*samp_rate/decimation/nfft)
    type: float
    vlen: nfft
  states: {state: disabled}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(0.1*samp_rate/decimation/nfft)
    type: float
    vlen: nfft
  states: {state: disabled}
- name: blocks_integrate_xx_1
  id: blocks_integrate_xx
  parameters:
    decim: int(0.001*samp_rate/decimation)
    type: float
  states: {state: disabled}
- name: blocks_integrate_xx_1_0
  id: blocks_integrate_xx
  parameters:
    decim: int(0.001*samp_rate/decimation)
    type: float
  states: {state: disabled}
- name: blocks_integrate_xx_2
  id: blocks_integrate_xx
  parameters:
    decim: '100'
    type: float
  states: {state: disabled}
- name: blocks_integrate_xx_2_0
  id: blocks_integrate_xx
  parameters:
    decim: '100'
    type: float
  states: {state: disabled}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    num_streams: '4'
    type: short
    vlen: '2'
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: nfft*2
    n: nfft*2*decimation
    offset: '0'
    type: short
  states: {state: disabled}
- name: blocks_keep_m_in_n_0_0
  id: blocks_keep_m_in_n
  parameters:
    m: nfft*2
    n: nfft*2*decimation
    offset: '0'
    type: short
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {state: disabled}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: float
    vlen: nfft
  states: {state: disabled}
- name: blocks_streams_to_vector_0_0
  id: blocks_streams_to_vector
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    type: short
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    type: short
  states: {state: disabled}
- name: directory
  id: parameter
  parameters:
    type: str
    value: '"/home/destevez/"'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {state: disabled}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {state: disabled}
- name: gaindB
  id: parameter
  parameters:
    label: rx gain in decibels
    short_id: g
    type: eng_float
    value: '50'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: sampling rate [Hz]
    short_id: b
    type: eng_float
    value: 30.72e6
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: print(datetime.utcnow())
    priority: ''
    section: main_after_init
  states: {}
- name: src_name
  id: parameter
  parameters:
    type: str
    value: '''unknown_source'''
  states: {}
- name: timestamp
  id: parameter
  parameters:
    type: str
    value: datetime.utcnow().isoformat()
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    ant1: RX2
    ant2: RX2
    ant3: RX2
    center_freq0: fc
    center_freq1: fc
    center_freq2: fc
    center_freq3: fc
    clock_rate: '0.0'
    clock_source0: external
    clock_source1: external
    dc_offs_enb0: 'False'
    dc_offs_enb1: 'False'
    dc_offs_enb2: '""'
    dc_offs_enb3: '""'
    dev_addr: '"addr0=10.11.2.61, addr1=10.11.2.71"'
    dev_args: '""'
    gain0: gaindB
    gain1: gaindB
    gain2: gaindB
    gain3: gaindB
    iq_imbal_enb0: 'False'
    iq_imbal_enb1: 'False'
    iq_imbal_enb2: '""'
    iq_imbal_enb3: '""'
    nchan: '4'
    norm_gain0: 'False'
    norm_gain1: 'False'
    norm_gain2: 'False'
    norm_gain3: 'False'
    num_mboards: '2'
    otw: sc16
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    time_source1: external
    type: sc16
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5555
    timeout: '100'
    type: float
    vlen: 2*nfft
  states: {state: disabled}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5556
    timeout: '100'
    type: float
    vlen: '2'
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_integrate_xx_1, '0']
- [blocks_complex_to_mag_squared_1_0, '0', blocks_integrate_xx_1_0, '0']
- [blocks_integrate_xx_0, '0', blocks_streams_to_vector_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_streams_to_vector_0, '1']
- [blocks_integrate_xx_1, '0', blocks_integrate_xx_2_0, '0']
- [blocks_integrate_xx_1_0, '0', blocks_integrate_xx_2, '0']
- [blocks_integrate_xx_2, '0', blocks_streams_to_vector_0_0, '1']
- [blocks_integrate_xx_2_0, '0', blocks_streams_to_vector_0_0, '0']
- [blocks_interleave_0, '0', blocks_file_meta_sink_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_complex_to_mag_squared_1, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', blocks_complex_to_mag_squared_1_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_keep_m_in_n_0_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_streams_to_vector_0, '0', zeromq_pub_sink_0, '0']
- [blocks_streams_to_vector_0_0, '0', zeromq_pub_sink_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_keep_m_in_n_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_meta_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_interleave_0, '0']
- [uhd_usrp_source_0, '0', blocks_vector_to_stream_0, '0']
- [uhd_usrp_source_0, '1', blocks_file_meta_sink_0_0, '0']
- [uhd_usrp_source_0, '1', blocks_interleave_0, '1']
- [uhd_usrp_source_0, '2', blocks_file_meta_sink_0_0_0, '0']
- [uhd_usrp_source_0, '2', blocks_interleave_0, '2']
- [uhd_usrp_source_0, '2', blocks_vector_to_stream_0_0, '0']
- [uhd_usrp_source_0, '3', blocks_file_meta_sink_0_0_0_0, '0']
- [uhd_usrp_source_0, '3', blocks_interleave_0, '3']

metadata:
  file_format: 1
