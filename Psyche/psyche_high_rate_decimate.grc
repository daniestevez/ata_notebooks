options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: psyche_high_rate_decimate
    output_language: python
    run_options: run
    title: Psyche high-rate decimate
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4.096e6
  states: {}
- name: basename
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: 127*gain
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_char_0_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: 127*gain
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_char_0_0_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: 127*gain
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_char_0_1
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: 127*gain
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: f'{output}_0x'
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: f'{output}_0y'
    type: byte
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: f'{output}_1x'
    type: byte
  states: {}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: f'{output}_1y'
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_0x'
    offset: int(2 * samp_rate * 5195)
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_0y'
    offset: int(2 * samp_rate * 5195)
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_1x'
    offset: int(2 * samp_rate * 5195)
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_1y'
    offset: int(2 * samp_rate * 5195)
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_1
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_2
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Gain
    type: eng_float
    value: '32.0'
  states: {}
- name: output
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}

connections:
- [blocks_complex_to_interleaved_char_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_interleaved_char_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_complex_to_interleaved_char_0_0_0, '0', blocks_file_sink_0_2, '0']
- [blocks_complex_to_interleaved_char_0_1, '0', blocks_file_sink_0_1, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_interleaved_short_to_complex_0_1, '0']
- [blocks_file_source_0_0_0_0, '0', blocks_interleaved_short_to_complex_0_2, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', blocks_complex_to_interleaved_char_0_0, '0']
- [blocks_interleaved_short_to_complex_0_1, '0', blocks_complex_to_interleaved_char_0_1, '0']
- [blocks_interleaved_short_to_complex_0_2, '0', blocks_complex_to_interleaved_char_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
