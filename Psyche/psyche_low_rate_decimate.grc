options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: psyche_low_rate_decimate
    output_language: python
    run_options: run
    title: Psyche low-rate decimate
  states: {}

blocks:
- name: dec
  id: variable
  parameters:
    value: '32'
  states: {}
- name: fir_taps
  id: variable
  parameters:
    value: firdes.low_pass(1, 1, 0.5/dec, 0.05/dec)
  states: {}
- name: freq
  id: variable
  parameters:
    value: 525e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4.096e6
  states: {}
- name: basename
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15*gain
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_short_0_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15*gain
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_short_0_0_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15*gain
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_short_0_0_1
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15*gain
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: f'{output}_0x'
    type: short
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: f'{output}_0y'
    type: short
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: f'{output}_1x'
    type: short
  states: {}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: f'{output}_1y'
    type: short
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_0x'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_0y'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_1x'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_1y'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_1
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_2
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq
    decim: dec
    samp_rate: samp_rate
    taps: fir_taps
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq
    decim: dec
    samp_rate: samp_rate
    taps: fir_taps
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq
    decim: dec
    samp_rate: samp_rate
    taps: fir_taps
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq
    decim: dec
    samp_rate: samp_rate
    taps: fir_taps
    type: ccf
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Gain
    type: eng_float
    value: '1.0'
  states: {}
- name: output
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_interleaved_short_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_complex_to_interleaved_short_0_0_0, '0', blocks_file_sink_0_1, '0']
- [blocks_complex_to_interleaved_short_0_0_1, '0', blocks_file_sink_0_2, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_interleaved_short_to_complex_0_1, '0']
- [blocks_file_source_0_0_0_0, '0', blocks_interleaved_short_to_complex_0_2, '0']
- [blocks_interleaved_short_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_interleaved_short_to_complex_0_1, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [blocks_interleaved_short_to_complex_0_2, '0', freq_xlating_fir_filter_xxx_0_0_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_complex_to_interleaved_short_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', blocks_complex_to_interleaved_short_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', blocks_complex_to_interleaved_short_0_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
