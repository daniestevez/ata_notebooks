options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: escapade_channelizer
    output_language: python
    run_options: run
    title: ESCAPADE channelizer
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '40'
  states: {}
- name: freq_blue
  id: variable
  parameters:
    value: '-2.9e6'
  states: {}
- name: freq_gold
  id: variable
  parameters:
    value: 3.1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10.24e6
  states: {}
- name: taps
  id: variable
  parameters:
    value: pm_remez.remez(1024, [0, 0.5 * 0.9 / decimation, 0.5 * 1.1 / decimation, 0.5], [1, 0], weight=[1, (10, 10 * 0.5 / (0.5 * 1.1 / decimation))]).impulse_response
  states: {}
- name: basename
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '125'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_char_0_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '125'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_char_0_0_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '125'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_char_0_0_1
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '125'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_char_0_0_2
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '125'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_char_0_1
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '125'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_char_0_2
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '125'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_char_0_3
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '125'
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: f'{output}_Gold_0x'
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: f'{output}_Blue_0x'
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: f'{output}_Blue_0y'
    type: byte
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: f'{output}_Blue_1x'
    type: byte
  states: {}
- name: blocks_file_sink_0_0_2
  id: blocks_file_sink
  parameters:
    file: f'{output}_Blue_1y'
    type: byte
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: f'{output}_Gold_0y'
    type: byte
  states: {}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: f'{output}_Gold_1x'
    type: byte
  states: {}
- name: blocks_file_sink_0_3
  id: blocks_file_sink
  parameters:
    file: f'{output}_Gold_1y'
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_0x'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_0y'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: f'{basename}_1y'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: f'{basename}_1x'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_0_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0_1
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_blue
    decim: decimation
    samp_rate: samp_rate
    taps: np.array(taps) * gain
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_gold
    decim: decimation
    samp_rate: samp_rate
    taps: np.array(taps) * gain
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_gold
    decim: decimation
    samp_rate: samp_rate
    taps: np.array(taps) * gain
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_gold
    decim: decimation
    samp_rate: samp_rate
    taps: np.array(taps) * gain
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_gold
    decim: decimation
    samp_rate: samp_rate
    taps: np.array(taps) * gain
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_blue
    decim: decimation
    samp_rate: samp_rate
    taps: np.array(taps) * gain
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_blue
    decim: decimation
    samp_rate: samp_rate
    taps: np.array(taps) * gain
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0_3
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_blue
    decim: decimation
    samp_rate: samp_rate
    taps: np.array(taps) * gain
    type: ccf
  states: {}
- name: gain
  id: parameter
  parameters:
    type: eng_float
    value: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pm_remez
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: output
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}

connections:
- [blocks_complex_to_interleaved_char_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_interleaved_char_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_complex_to_interleaved_char_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_complex_to_interleaved_char_0_0_1, '0', blocks_file_sink_0_0_1, '0']
- [blocks_complex_to_interleaved_char_0_0_2, '0', blocks_file_sink_0_0_2, '0']
- [blocks_complex_to_interleaved_char_0_1, '0', blocks_file_sink_0_1, '0']
- [blocks_complex_to_interleaved_char_0_2, '0', blocks_file_sink_0_2, '0']
- [blocks_complex_to_interleaved_char_0_3, '0', blocks_file_sink_0_3, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_interleaved_short_to_complex_0_0_0, '0']
- [blocks_file_source_0_1, '0', blocks_interleaved_short_to_complex_0_1, '0']
- [blocks_interleaved_short_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [blocks_interleaved_short_to_complex_0_0, '0', freq_xlating_fir_filter_xxx_0_1, '0']
- [blocks_interleaved_short_to_complex_0_0_0, '0', freq_xlating_fir_filter_xxx_0_0_2, '0']
- [blocks_interleaved_short_to_complex_0_0_0, '0', freq_xlating_fir_filter_xxx_0_3, '0']
- [blocks_interleaved_short_to_complex_0_1, '0', freq_xlating_fir_filter_xxx_0_0_1, '0']
- [blocks_interleaved_short_to_complex_0_1, '0', freq_xlating_fir_filter_xxx_0_2, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_interleaved_char_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', blocks_complex_to_interleaved_char_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', blocks_complex_to_interleaved_char_0_2, '0']
- [freq_xlating_fir_filter_xxx_0_0_2, '0', blocks_complex_to_interleaved_char_0_3, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', blocks_complex_to_interleaved_char_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_2, '0', blocks_complex_to_interleaved_char_0_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_3, '0', blocks_complex_to_interleaved_char_0_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
